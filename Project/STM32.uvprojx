# Keil uVision project STM32.uvprojx, settings and files
target Stm32 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD
  c include: ..\Libraries;..\Application\LED;..\Application\BEEP;..\Application\KEY;..\Application\SYS;..\Application\DELAY
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Libraries
    ../Libraries/: core_cm3.c startup_stm32f10x_hd.s system_stm32f10x.c
  group Application
    ../Application/LED/: led.c
    ../Application/BEEP/: beep.c
    ../Application/KEY/: key.c
    ../Application/SYS/: sys.c
    ../Application/DELAY/: delay.c
  group Core
    ../Core/: main.c
